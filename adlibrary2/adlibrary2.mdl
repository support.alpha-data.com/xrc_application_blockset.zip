simulink library "adlibrary2"  (Simulink 6.6)
undefined symbols (not defined in the file or in its folder): adlibrary2, ADM, DDRII, DRAM, II, no_bitstream, SRAM, SX, XP, XRC
libraries: xbsIndex_r4 x470, adlibrary2 x13, adlibrary2_ddr2dram_1 x8, adlibrary2_ddr2dram5t1_1 x6, adlibrary2_d2sram_0 x5, adlibrary2_ddr_xpi0 x4, adlibrary2_ddr_xpl x3, adlibrary2_xpl32 x1, adlibrary2_xpl64 x1, adlibrary2_zbt64 x1, adlibrary2_zbt4_0 x1, adlibrary2_zbt4_1 x1
(part 3 of 3)

== system adlibrary2/ADM-XRC-II/XRM DDR SDRAM /Configurable Subsystem ==
  cache_data_in : Inport
  cache_addr : Inport  Port=2
  cache_write : Inport  Port=3
  ddr_page : Inport  Port=4
  ddr_addr : Inport  Port=5
  ddr_read : Inport  Port=6
  ddr_write : Inport  Port=7
  DDR SDRAM 64bit Simulation : adlibrary2_ddr_xrm/DDR SDRAM 64bit Simulation  SystemSampleTime=-1  memsize=memsize
  cache_data_out : Outport
  ddr_busy : Outport  Port=2
  wires:
  cache_data_in/1 -> DDR SDRAM 64bit Simulation/1
  cache_addr/1 -> DDR SDRAM 64bit Simulation/2
  cache_write/1 -> DDR SDRAM 64bit Simulation/3
  ddr_page/1 -> DDR SDRAM 64bit Simulation/4
  ddr_addr/1 -> DDR SDRAM 64bit Simulation/5
  ddr_read/1 -> DDR SDRAM 64bit Simulation/6
  ddr_write/1 -> DDR SDRAM 64bit Simulation/7
  DDR SDRAM 64bit Simulation/1 -> cache_data_out/1
  DDR SDRAM 64bit Simulation/2 -> ddr_busy/1

== system adlibrary2/ADM-XRC-II/ZBT SRAM 0/Configurable Subsystem ==
  d : Inport
  a : Inport  Port=2
  w : Inport  Port=3
  r : Inport  Port=4
  be : Inport  Port=5
  adlocb_in : Inport  Port=6
  ZBT SRAM 32Bit Simulation : adlibrary2_zbt32_0/ZBT SRAM 32Bit Simulation  SystemSampleTime=-1
  q : Outport
  qv : Outport  Port=2
  adlocb_out : Outport  Port=3
  wires:
  d/1 -> ZBT SRAM 32Bit Simulation/1
  a/1 -> ZBT SRAM 32Bit Simulation/2
  w/1 -> ZBT SRAM 32Bit Simulation/3
  r/1 -> ZBT SRAM 32Bit Simulation/4
  be/1 -> ZBT SRAM 32Bit Simulation/5
  adlocb_in/1 -> ZBT SRAM 32Bit Simulation/6
  ZBT SRAM 32Bit Simulation/1 -> q/1
  ZBT SRAM 32Bit Simulation/2 -> qv/1
  ZBT SRAM 32Bit Simulation/3 -> adlocb_out/1

== system adlibrary2/ADM-XRC-II/ZBT SRAM 1/Configurable Subsystem ==
  d : Inport
  a : Inport  Port=2
  w : Inport  Port=3
  r : Inport  Port=4
  be : Inport  Port=5
  adlocb_in : Inport  Port=6
  ZBT SRAM 32Bit Simulation : adlibrary2_zbt32_1/ZBT SRAM 32Bit Simulation  SystemSampleTime=-1
  q : Outport
  qv : Outport  Port=2
  adlocb_out : Outport  Port=3
  wires:
  d/1 -> ZBT SRAM 32Bit Simulation/1
  a/1 -> ZBT SRAM 32Bit Simulation/2
  w/1 -> ZBT SRAM 32Bit Simulation/3
  r/1 -> ZBT SRAM 32Bit Simulation/4
  be/1 -> ZBT SRAM 32Bit Simulation/5
  adlocb_in/1 -> ZBT SRAM 32Bit Simulation/6
  ZBT SRAM 32Bit Simulation/1 -> q/1
  ZBT SRAM 32Bit Simulation/2 -> qv/1
  ZBT SRAM 32Bit Simulation/3 -> adlocb_out/1

== system adlibrary2/ADM-XRC-II/ZBT SRAM 2/Configurable Subsystem ==
  d : Inport
  a : Inport  Port=2
  w : Inport  Port=3
  r : Inport  Port=4
  be : Inport  Port=5
  adlocb_in : Inport  Port=6
  ZBT SRAM 32Bit Simulation : adlibrary2_zbt32_2/ZBT SRAM 32Bit Simulation  SystemSampleTime=-1
  q : Outport
  qv : Outport  Port=2
  adlocb_out : Outport  Port=3
  wires:
  d/1 -> ZBT SRAM 32Bit Simulation/1
  a/1 -> ZBT SRAM 32Bit Simulation/2
  w/1 -> ZBT SRAM 32Bit Simulation/3
  r/1 -> ZBT SRAM 32Bit Simulation/4
  be/1 -> ZBT SRAM 32Bit Simulation/5
  adlocb_in/1 -> ZBT SRAM 32Bit Simulation/6
  ZBT SRAM 32Bit Simulation/1 -> q/1
  ZBT SRAM 32Bit Simulation/2 -> qv/1
  ZBT SRAM 32Bit Simulation/3 -> adlocb_out/1

== system adlibrary2/ADM-XRC-II/ZBT SRAM 3/Configurable Subsystem ==
  d : Inport
  a : Inport  Port=2
  w : Inport  Port=3
  r : Inport  Port=4
  be : Inport  Port=5
  adlocb_in : Inport  Port=6
  ZBT SRAM 32Bit Simulation : adlibrary2_zbt32_3/ZBT SRAM 32Bit Simulation  SystemSampleTime=-1
  q : Outport
  qv : Outport  Port=2
  adlocb_out : Outport  Port=3
  wires:
  d/1 -> ZBT SRAM 32Bit Simulation/1
  a/1 -> ZBT SRAM 32Bit Simulation/2
  w/1 -> ZBT SRAM 32Bit Simulation/3
  r/1 -> ZBT SRAM 32Bit Simulation/4
  be/1 -> ZBT SRAM 32Bit Simulation/5
  adlocb_in/1 -> ZBT SRAM 32Bit Simulation/6
  ZBT SRAM 32Bit Simulation/1 -> q/1
  ZBT SRAM 32Bit Simulation/2 -> qv/1
  ZBT SRAM 32Bit Simulation/3 -> adlocb_out/1

== system adlibrary2/ADM-XRC-II/ZBT SRAM 4/Configurable Subsystem ==
  d : Inport
  a : Inport  Port=2
  w : Inport  Port=3
  r : Inport  Port=4
  be : Inport  Port=5
  adlocb_in : Inport  Port=6
  ZBT SRAM 32Bit Simulation : adlibrary2_zbt32_4/ZBT SRAM 32Bit Simulation  SystemSampleTime=-1
  q : Outport
  qv : Outport  Port=2
  adlocb_out : Outport  Port=3
  wires:
  d/1 -> ZBT SRAM 32Bit Simulation/1
  a/1 -> ZBT SRAM 32Bit Simulation/2
  w/1 -> ZBT SRAM 32Bit Simulation/3
  r/1 -> ZBT SRAM 32Bit Simulation/4
  be/1 -> ZBT SRAM 32Bit Simulation/5
  adlocb_in/1 -> ZBT SRAM 32Bit Simulation/6
  ZBT SRAM 32Bit Simulation/1 -> q/1
  ZBT SRAM 32Bit Simulation/2 -> qv/1
  ZBT SRAM 32Bit Simulation/3 -> adlocb_out/1

== system adlibrary2/ADM-XRC-II/ZBT SRAM 5/Configurable Subsystem ==
  d : Inport
  a : Inport  Port=2
  w : Inport  Port=3
  r : Inport  Port=4
  be : Inport  Port=5
  adlocb_in : Inport  Port=6
  ZBT SRAM 32Bit Simulation : adlibrary2_zbt32_5/ZBT SRAM 32Bit Simulation  SystemSampleTime=-1
  q : Outport
  qv : Outport  Port=2
  adlocb_out : Outport  Port=3
  wires:
  d/1 -> ZBT SRAM 32Bit Simulation/1
  a/1 -> ZBT SRAM 32Bit Simulation/2
  w/1 -> ZBT SRAM 32Bit Simulation/3
  r/1 -> ZBT SRAM 32Bit Simulation/4
  be/1 -> ZBT SRAM 32Bit Simulation/5
  adlocb_in/1 -> ZBT SRAM 32Bit Simulation/6
  ZBT SRAM 32Bit Simulation/1 -> q/1
  ZBT SRAM 32Bit Simulation/2 -> qv/1
  ZBT SRAM 32Bit Simulation/3 -> adlocb_out/1

== system adlibrary2/ADP-XPI/DDR SDRAM 0/Configurable Subsystem ==
  cache_data_in : Inport
  cache_addr : Inport  Port=2
  cache_write : Inport  Port=3
  ddr_page : Inport  Port=4
  ddr_addr : Inport  Port=5
  ddr_read : Inport  Port=6
  ddr_write : Inport  Port=7
  DDR SDRAM 64bit Simulation : adlibrary2_ddr_xpi0/DDR SDRAM 64bit Simulation  SystemSampleTime=-1  memsize=memsize
  cache_data_out : Outport
  ddr_busy : Outport  Port=2
  wires:
  cache_data_in/1 -> DDR SDRAM 64bit Simulation/1
  cache_addr/1 -> DDR SDRAM 64bit Simulation/2
  cache_write/1 -> DDR SDRAM 64bit Simulation/3
  ddr_page/1 -> DDR SDRAM 64bit Simulation/4
  ddr_addr/1 -> DDR SDRAM 64bit Simulation/5
  ddr_read/1 -> DDR SDRAM 64bit Simulation/6
  ddr_write/1 -> DDR SDRAM 64bit Simulation/7
  DDR SDRAM 64bit Simulation/1 -> cache_data_out/1
  DDR SDRAM 64bit Simulation/2 -> ddr_busy/1

== system adlibrary2/ADP-XPI/DDR SDRAM 1/Configurable Subsystem ==
  cache_data_in : Inport
  cache_addr : Inport  Port=2
  cache_write : Inport  Port=3
  ddr_page : Inport  Port=4
  ddr_addr : Inport  Port=5
  ddr_read : Inport  Port=6
  ddr_write : Inport  Port=7
  DDR SDRAM 64bit Simulation : adlibrary2_ddr_xpi0/DDR SDRAM 64bit Simulation  SystemSampleTime=-1  memsize=memsize
  cache_data_out : Outport
  ddr_busy : Outport  Port=2
  wires:
  cache_data_in/1 -> DDR SDRAM 64bit Simulation/1
  cache_addr/1 -> DDR SDRAM 64bit Simulation/2
  cache_write/1 -> DDR SDRAM 64bit Simulation/3
  ddr_page/1 -> DDR SDRAM 64bit Simulation/4
  ddr_addr/1 -> DDR SDRAM 64bit Simulation/5
  ddr_read/1 -> DDR SDRAM 64bit Simulation/6
  ddr_write/1 -> DDR SDRAM 64bit Simulation/7
  DDR SDRAM 64bit Simulation/1 -> cache_data_out/1
  DDR SDRAM 64bit Simulation/2 -> ddr_busy/1

== system adlibrary2/ADP-XPI/DDR SDRAM 2/Configurable Subsystem ==
  cache_data_in : Inport
  cache_addr : Inport  Port=2
  cache_write : Inport  Port=3
  ddr_page : Inport  Port=4
  ddr_addr : Inport  Port=5
  ddr_read : Inport  Port=6
  ddr_write : Inport  Port=7
  DDR SDRAM 64bit Simulation : adlibrary2_ddr_xpi0/DDR SDRAM 64bit Simulation  SystemSampleTime=-1  memsize=memsize
  cache_data_out : Outport
  ddr_busy : Outport  Port=2
  wires:
  cache_data_in/1 -> DDR SDRAM 64bit Simulation/1
  cache_addr/1 -> DDR SDRAM 64bit Simulation/2
  cache_write/1 -> DDR SDRAM 64bit Simulation/3
  ddr_page/1 -> DDR SDRAM 64bit Simulation/4
  ddr_addr/1 -> DDR SDRAM 64bit Simulation/5
  ddr_read/1 -> DDR SDRAM 64bit Simulation/6
  ddr_write/1 -> DDR SDRAM 64bit Simulation/7
  DDR SDRAM 64bit Simulation/1 -> cache_data_out/1
  DDR SDRAM 64bit Simulation/2 -> ddr_busy/1

== system adlibrary2/ADP-XPI/DDR SDRAM 3/Configurable Subsystem ==
  cache_data_in : Inport
  cache_addr : Inport  Port=2
  cache_write : Inport  Port=3
  ddr_page : Inport  Port=4
  ddr_addr : Inport  Port=5
  ddr_read : Inport  Port=6
  ddr_write : Inport  Port=7
  DDR SDRAM 64bit Simulation : adlibrary2_ddr_xpi0/DDR SDRAM 64bit Simulation  SystemSampleTime=-1  memsize=memsize
  cache_data_out : Outport
  ddr_busy : Outport  Port=2
  wires:
  cache_data_in/1 -> DDR SDRAM 64bit Simulation/1
  cache_addr/1 -> DDR SDRAM 64bit Simulation/2
  cache_write/1 -> DDR SDRAM 64bit Simulation/3
  ddr_page/1 -> DDR SDRAM 64bit Simulation/4
  ddr_addr/1 -> DDR SDRAM 64bit Simulation/5
  ddr_read/1 -> DDR SDRAM 64bit Simulation/6
  ddr_write/1 -> DDR SDRAM 64bit Simulation/7
  DDR SDRAM 64bit Simulation/1 -> cache_data_out/1
  DDR SDRAM 64bit Simulation/2 -> ddr_busy/1

== system adlibrary2/ADP-XPI/DDRII SRAM 0/Configurable Subsystem ==
  d : Inport
  a : Inport  Port=2
  w : Inport  Port=3
  r : Inport  Port=4
  be : Inport  Port=5
  adlocb_in : Inport  Port=6
  DDRII SRAM Simulation : adlibrary2_d2sram_0/DDRII SRAM Simulation  SystemSampleTime=-1
  q : Outport
  qv : Outport  Port=2
  adlocb_out : Outport  Port=3
  wires:
  d/1 -> DDRII SRAM Simulation/1
  a/1 -> DDRII SRAM Simulation/2
  w/1 -> DDRII SRAM Simulation/3
  r/1 -> DDRII SRAM Simulation/4
  be/1 -> DDRII SRAM Simulation/5
  adlocb_in/1 -> DDRII SRAM Simulation/6
  DDRII SRAM Simulation/1 -> q/1
  DDRII SRAM Simulation/2 -> qv/1
  DDRII SRAM Simulation/3 -> adlocb_out/1

== system adlibrary2/ADPe-XRC4/DDRII DRAM 0/Configurable Subsystem ==
  d : Inport
  a : Inport  Port=2
  w : Inport  Port=3
  r : Inport  Port=4
  be : Inport  Port=5
  adlocb_in : Inport  Port=6
  DDRII DRAM Simulation : adlibrary2_ddr2dram_1/DDRII DRAM Simulation  SystemSampleTime=-1
  q : Outport
  qv : Outport  Port=2
  full : Outport  Port=3
  adlocb_out : Outport  Port=4
  wires:
  DDRII DRAM Simulation/4 -> adlocb_out/1
  DDRII DRAM Simulation/3 -> full/1
  DDRII DRAM Simulation/2 -> qv/1
  DDRII DRAM Simulation/1 -> q/1
  adlocb_in/1 -> DDRII DRAM Simulation/6
  be/1 -> DDRII DRAM Simulation/5
  r/1 -> DDRII DRAM Simulation/4
  w/1 -> DDRII DRAM Simulation/3
  a/1 -> DDRII DRAM Simulation/2
  d/1 -> DDRII DRAM Simulation/1

== system adlibrary2/ADPe-XRC4/DDRII DRAM 1/Configurable Subsystem ==
  d : Inport
  a : Inport  Port=2
  w : Inport  Port=3
  r : Inport  Port=4
  be : Inport  Port=5
  adlocb_in : Inport  Port=6
  DDRII DRAM Generation : adlibrary2_ddr2dram_1/DDRII DRAM Generation  SystemSampleTime=-1
  q : Outport
  qv : Outport  Port=2
  full : Outport  Port=3
  adlocb_out : Outport  Port=4
  wires:
  DDRII DRAM Generation/4 -> adlocb_out/1
  DDRII DRAM Generation/3 -> full/1
  DDRII DRAM Generation/2 -> qv/1
  DDRII DRAM Generation/1 -> q/1
  adlocb_in/1 -> DDRII DRAM Generation/6
  be/1 -> DDRII DRAM Generation/5
  r/1 -> DDRII DRAM Generation/4
  w/1 -> DDRII DRAM Generation/3
  a/1 -> DDRII DRAM Generation/2
  d/1 -> DDRII DRAM Generation/1

== system adlibrary2/ADPe-XRC4/DDRII DRAM 2/Configurable Subsystem ==
  d : Inport
  a : Inport  Port=2
  w : Inport  Port=3
  r : Inport  Port=4
  be : Inport  Port=5
  adlocb_in : Inport  Port=6
  DDRII DRAM Generation : adlibrary2_ddr2dram_1/DDRII DRAM Generation  SystemSampleTime=-1
  q : Outport
  qv : Outport  Port=2
  full : Outport  Port=3
  adlocb_out : Outport  Port=4
  wires:
  DDRII DRAM Generation/4 -> adlocb_out/1
  DDRII DRAM Generation/3 -> full/1
  DDRII DRAM Generation/2 -> qv/1
  DDRII DRAM Generation/1 -> q/1
  adlocb_in/1 -> DDRII DRAM Generation/6
  be/1 -> DDRII DRAM Generation/5
  r/1 -> DDRII DRAM Generation/4
  w/1 -> DDRII DRAM Generation/3
  a/1 -> DDRII DRAM Generation/2
  d/1 -> DDRII DRAM Generation/1

== system adlibrary2/ADPe-XRC4/DDRII DRAM 3/Configurable Subsystem ==
  d : Inport
  a : Inport  Port=2
  w : Inport  Port=3
  r : Inport  Port=4
  be : Inport  Port=5
  adlocb_in : Inport  Port=6
  DDRII DRAM Generation : adlibrary2_ddr2dram_1/DDRII DRAM Generation  SystemSampleTime=-1
  q : Outport
  qv : Outport  Port=2
  full : Outport  Port=3
  adlocb_out : Outport  Port=4
  wires:
  DDRII DRAM Generation/4 -> adlocb_out/1
  DDRII DRAM Generation/3 -> full/1
  DDRII DRAM Generation/2 -> qv/1
  DDRII DRAM Generation/1 -> q/1
  adlocb_in/1 -> DDRII DRAM Generation/6
  be/1 -> DDRII DRAM Generation/5
  r/1 -> DDRII DRAM Generation/4
  w/1 -> DDRII DRAM Generation/3
  a/1 -> DDRII DRAM Generation/2
  d/1 -> DDRII DRAM Generation/1
