simulink library "adlibrary2"  (Simulink 6.6)
undefined symbols (not defined in the file or in its folder): adlibrary2, ADM, DDRII, DRAM, II, no_bitstream, SRAM, SX, XP, XRC
libraries: xbsIndex_r4 x430, adlibrary2 x11, adlibrary2_ddr2dram5t1_1 x6, adlibrary2_d2sram_0 x5, adlibrary2_ddr2dram_1 x4, adlibrary2_ddr_xpi0 x4, adlibrary2_ddr_xpl x3, adlibrary2_xpl32 x1, adlibrary2_xpl64 x1, adlibrary2_zbt64 x1, adlibrary2_zbt4_0 x1, adlibrary2_zbt4_1 x1
(part 3 of 3)

== system adlibrary2/ADP-XPI/DDR SDRAM 0/Configurable Subsystem ==
  cache_data_in : Inport
  cache_addr : Inport  Port=2
  cache_write : Inport  Port=3
  ddr_page : Inport  Port=4
  ddr_addr : Inport  Port=5
  ddr_read : Inport  Port=6
  ddr_write : Inport  Port=7
  DDR SDRAM 64bit Simulation : adlibrary2_ddr_xpi0/DDR SDRAM 64bit Simulation  SystemSampleTime=-1  memsize=memsize
  cache_data_out : Outport
  ddr_busy : Outport  Port=2
  wires:
  cache_data_in/1 -> DDR SDRAM 64bit Simulation/1
  cache_addr/1 -> DDR SDRAM 64bit Simulation/2
  cache_write/1 -> DDR SDRAM 64bit Simulation/3
  ddr_page/1 -> DDR SDRAM 64bit Simulation/4
  ddr_addr/1 -> DDR SDRAM 64bit Simulation/5
  ddr_read/1 -> DDR SDRAM 64bit Simulation/6
  ddr_write/1 -> DDR SDRAM 64bit Simulation/7
  DDR SDRAM 64bit Simulation/1 -> cache_data_out/1
  DDR SDRAM 64bit Simulation/2 -> ddr_busy/1

== system adlibrary2/ADP-XPI/DDR SDRAM 1/Configurable Subsystem ==
  cache_data_in : Inport
  cache_addr : Inport  Port=2
  cache_write : Inport  Port=3
  ddr_page : Inport  Port=4
  ddr_addr : Inport  Port=5
  ddr_read : Inport  Port=6
  ddr_write : Inport  Port=7
  DDR SDRAM 64bit Simulation : adlibrary2_ddr_xpi0/DDR SDRAM 64bit Simulation  SystemSampleTime=-1  memsize=memsize
  cache_data_out : Outport
  ddr_busy : Outport  Port=2
  wires:
  cache_data_in/1 -> DDR SDRAM 64bit Simulation/1
  cache_addr/1 -> DDR SDRAM 64bit Simulation/2
  cache_write/1 -> DDR SDRAM 64bit Simulation/3
  ddr_page/1 -> DDR SDRAM 64bit Simulation/4
  ddr_addr/1 -> DDR SDRAM 64bit Simulation/5
  ddr_read/1 -> DDR SDRAM 64bit Simulation/6
  ddr_write/1 -> DDR SDRAM 64bit Simulation/7
  DDR SDRAM 64bit Simulation/1 -> cache_data_out/1
  DDR SDRAM 64bit Simulation/2 -> ddr_busy/1

== system adlibrary2/ADP-XPI/DDR SDRAM 2/Configurable Subsystem ==
  cache_data_in : Inport
  cache_addr : Inport  Port=2
  cache_write : Inport  Port=3
  ddr_page : Inport  Port=4
  ddr_addr : Inport  Port=5
  ddr_read : Inport  Port=6
  ddr_write : Inport  Port=7
  DDR SDRAM 64bit Simulation : adlibrary2_ddr_xpi0/DDR SDRAM 64bit Simulation  SystemSampleTime=-1  memsize=memsize
  cache_data_out : Outport
  ddr_busy : Outport  Port=2
  wires:
  cache_data_in/1 -> DDR SDRAM 64bit Simulation/1
  cache_addr/1 -> DDR SDRAM 64bit Simulation/2
  cache_write/1 -> DDR SDRAM 64bit Simulation/3
  ddr_page/1 -> DDR SDRAM 64bit Simulation/4
  ddr_addr/1 -> DDR SDRAM 64bit Simulation/5
  ddr_read/1 -> DDR SDRAM 64bit Simulation/6
  ddr_write/1 -> DDR SDRAM 64bit Simulation/7
  DDR SDRAM 64bit Simulation/1 -> cache_data_out/1
  DDR SDRAM 64bit Simulation/2 -> ddr_busy/1

== system adlibrary2/ADP-XPI/DDR SDRAM 3/Configurable Subsystem ==
  cache_data_in : Inport
  cache_addr : Inport  Port=2
  cache_write : Inport  Port=3
  ddr_page : Inport  Port=4
  ddr_addr : Inport  Port=5
  ddr_read : Inport  Port=6
  ddr_write : Inport  Port=7
  DDR SDRAM 64bit Simulation : adlibrary2_ddr_xpi0/DDR SDRAM 64bit Simulation  SystemSampleTime=-1  memsize=memsize
  cache_data_out : Outport
  ddr_busy : Outport  Port=2
  wires:
  cache_data_in/1 -> DDR SDRAM 64bit Simulation/1
  cache_addr/1 -> DDR SDRAM 64bit Simulation/2
  cache_write/1 -> DDR SDRAM 64bit Simulation/3
  ddr_page/1 -> DDR SDRAM 64bit Simulation/4
  ddr_addr/1 -> DDR SDRAM 64bit Simulation/5
  ddr_read/1 -> DDR SDRAM 64bit Simulation/6
  ddr_write/1 -> DDR SDRAM 64bit Simulation/7
  DDR SDRAM 64bit Simulation/1 -> cache_data_out/1
  DDR SDRAM 64bit Simulation/2 -> ddr_busy/1

== system adlibrary2/ADP-XPI/DDRII SRAM 0/Configurable Subsystem ==
  d : Inport
  a : Inport  Port=2
  w : Inport  Port=3
  r : Inport  Port=4
  be : Inport  Port=5
  adlocb_in : Inport  Port=6
  DDRII SRAM Simulation : adlibrary2_d2sram_0/DDRII SRAM Simulation  SystemSampleTime=-1
  q : Outport
  qv : Outport  Port=2
  adlocb_out : Outport  Port=3
  wires:
  d/1 -> DDRII SRAM Simulation/1
  a/1 -> DDRII SRAM Simulation/2
  w/1 -> DDRII SRAM Simulation/3
  r/1 -> DDRII SRAM Simulation/4
  be/1 -> DDRII SRAM Simulation/5
  adlocb_in/1 -> DDRII SRAM Simulation/6
  DDRII SRAM Simulation/1 -> q/1
  DDRII SRAM Simulation/2 -> qv/1
  DDRII SRAM Simulation/3 -> adlocb_out/1
